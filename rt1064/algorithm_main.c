#include "sokoban_engine.h"
#include <string.h>
#include <stdlib.h>
#include <stdio.h>
#include <time.h>

#ifdef _WIN32
    #include <windows.h>
    #include <psapi.h>
    #pragma comment(lib, "psapi.lib") // 如果用 MSVC 编译需要这个
#else
    #include <sys/resource.h>
#endif

// // 0=空地 1=墙体 2=箱子 3=目的地 4=炸弹 5=小车
const uint8_t map_lhn[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
    1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 3, 1,
    1, 0, 0, 0, 1, 0, 0, 1, 2, 1, 1, 1, 1, 0, 0, 1,
    1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1,
    1, 0, 3, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0, 1,
    1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1,
    1, 0, 4, 0, 0, 0, 0, 0, 0, 0, 0, 4, 0, 1, 0, 1,
    1, 5, 0, 2, 0, 1, 0, 0, 0, 0, 0, 2, 4, 0, 0, 1,
    1, 0, 2, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1,
    1, 0, 0, 0, 0, 1, 3, 0, 3, 0, 0, 0, 0, 0, 0, 1,
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1
};
const uint8_t system_map3[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
    1, 5, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 3, 1,
    1, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1,
    1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1,
    1, 0, 3, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0, 1,
    1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1,
    1, 0, 4, 0, 0, 0, 0, 0, 0, 0, 4, 0, 1, 0, 0, 1,
    1, 0, 0, 2, 0, 1, 0, 0, 0, 0, 0, 2, 4, 0, 0, 1,
    1, 0, 2, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1,
    1, 0, 0, 0, 0, 1, 3, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1
};
const uint8_t map1_[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, // R0
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R1
    1, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, // R2
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R3
    1, 0, 0, 0, 0, 0, 0, 2, 0, 3, 3, 0, 0, 0, 0, 1, // R4
    1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R5
    1, 5, 0, 0, 0, 0, 0, 2, 0, 0, 1, 0, 0, 0, 0, 1, // R6
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, // R7
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R8
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R9
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, // R10
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1  // R11
};
const uint8_t map2[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
    1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 3, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1,
    1, 1, 2, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1,
    1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 3, 1, 0, 1, 0, 1,
    1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3, 1, 0, 1, 0, 1,
    1, 5, 0, 0, 0, 0, 0, 0, 2, 0, 0, 2, 0, 1, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1
};
const uint8_t map2cxg[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
    1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 3, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1,
    1, 1, 2, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1,
    1, 0, 4, 0, 0, 1, 0, 0, 0, 1, 3, 1, 0, 1, 0, 1,
    1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3, 1, 0, 1, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 2, 0, 4, 2, 0, 1, 0, 1,
    1, 0, 5, 0, 0, 0, 0, 0, 0, 0, 0, 4, 1, 1, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1,
    1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1
};
const uint8_t b1[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, // R0
    1, 0, 0, 0, 0, 1, 0, 3, 0, 0, 1, 1, 1, 1, 1, 1, // R1
    1, 3, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 2, 0, 0, 1, // R2
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, // R3
    1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, // R4
    1, 5, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, // R5
    1, 0, 0, 0, 0, 1, 0, 2, 0, 0, 0, 1, 1, 0, 3, 1, // R6
    1, 0, 4, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, // R7
    1, 0, 0, 0, 0, 1, 0, 2, 0, 0, 0, 0, 0, 0, 0, 1, // R8
    1, 0, 0, 2, 0, 1, 0, 0, 4, 0, 0, 0, 1, 1, 1, 1, // R9
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 3, 1, // R10
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1  // R11
};
const uint8_t m12[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, // R0
    1, 1, 1, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 3, 1, 1, // R1
    1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, // R2
    1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 2, 0, 1, // R3
    1, 0, 0, 0, 2, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, // R4
    1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, // R5
    1, 5, 0, 0, 1, 0, 0, 0, 0, 3, 0, 1, 0, 2, 0, 1, // R6
    1, 0, 3, 0, 0, 2, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, // R7
    1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, // R8
    1, 1, 1, 1, 0, 0, 0, 0, 3, 0, 1, 0, 1, 1, 1, 1, // R9
    1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, // R10
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1  // R11
};
const uint8_t b678[192] = {
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, // R0
    1, 3, 2, 0, 0, 1, 0, 3, 3, 3, 1, 1, 1, 1, 1, 1, // R1
    1, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0, 2, 0, 0, 1, // R2
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, // R3
    1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, // R4
    1, 0, 0, 0, 0, 1, 2, 0, 0, 0, 0, 1, 1, 0, 0, 1, // R5
    1, 5, 4, 0, 0, 1, 2, 0, 0, 0, 0, 1, 1, 0, 3, 1, // R6
    1, 0, 4, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, // R7
    1, 0, 0, 0, 0, 1, 0, 2, 0, 0, 0, 0, 0, 0, 0, 1, // R8
    1, 0, 0, 2, 0, 1, 0, 0, 4, 0, 0, 0, 1, 1, 1, 1, // R9
    1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 3, 1, // R10
    1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1  // R11
};
// 分配全局引擎上下文
SokobanContext engine_ctx;

int main(void) {
    printf("Sokoban C-Engine Starting...\n");
    printf("Map Size: %d x %d (Total: %d cells)\n\n", WIDTH, HEIGHT, MAP_SIZE);

    clock_t start_time = clock();
    build_map_info(&engine_ctx, b678, 0);
    bool success = solve(&engine_ctx);
    clock_t end_time = clock();

    double time_spent = (double)(end_time - start_time) / CLOCKS_PER_SEC;
    printf("\n========================================\n");
    if (success) {
        printf("成功获取了 %d 组微观行驶点集。\n", engine_ctx.solution_actions_len);
        // 生成完整轨迹
        WaypointPath path;
        path.length = 0;
        generate_path(&engine_ctx, &path);

        //调试 最终路径
        for(int i = 0; i < path.length; i++) {
            int px = path.points[i] % WIDTH;
            int py = path.points[i] / WIDTH;
            printf("(%d,%d)", px, py);
            if (i < path.length - 1) printf(" -> ");
            else printf("\n");
        }

        // 运控处理

    } else {
        printf("求解失败：无可行解或已触发节点防爆保护。\n");
    }
    double peak_memory_mb = 0.0;
#ifdef _WIN32
    PROCESS_MEMORY_COUNTERS pmc;
    if (GetProcessMemoryInfo(GetCurrentProcess(), &pmc, sizeof(pmc))) {
        peak_memory_mb = (double)pmc.PeakWorkingSetSize / (1024.0 * 1024.0);
    }
#else
    struct rusage r_usage;
    getrusage(RUSAGE_SELF, &r_usage);
    // 注意：Linux 的 ru_maxrss 单位是 KB，macOS 的单位是 Byte
    #ifdef __APPLE__
        peak_memory_mb = (double)r_usage.ru_maxrss / (1024.0 * 1024.0);
    #else
        peak_memory_mb = (double)r_usage.ru_maxrss / 1024.0;
    #endif
#endif
    printf(" 寻路耗时      : %.4f 秒\n", time_spent);
    printf(" 峰值内存占用  : %.4f MB\n", peak_memory_mb);
    printf(" Step          : %d\n", engine_ctx.solution_actions_len);


    return 0;
}
